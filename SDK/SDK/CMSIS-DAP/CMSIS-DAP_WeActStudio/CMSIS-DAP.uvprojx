# Keil uVision project CMSIS-DAP.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CMSIS-DAP_WeActStudio +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: _RTE_
  c include: .\User\Inc;.\CMSIS-DAP\Include;.\RTE\USB;..\CMSIS-DAP_WeActStudio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./: main.c
    ./User/Src/: USBD_User_HID_0.c STM32ID.c USBD_User_CustomClass_0.c
    ./User/Inc/: IO_Config.h DAP_config.h osObjects.h
  group CMSIS-DAP
    ./CMSIS-DAP/Source/: DAP.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
    ./CMSIS-DAP/Include/: DAP.h
software components: CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Compiler:Event Recorder 1.4.0, USB:CORE 6.14.0, USB:Device 6.14.0, USB:Device:HID 6.14.0, CMSIS Driver:SPI 2.12, CMSIS Driver:USART 2.12, CMSIS Driver:USB Device:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:SPI 1.7.6, Device:STM32Cube HAL:USART 1.7.6, Device:Startup 2.6.3
